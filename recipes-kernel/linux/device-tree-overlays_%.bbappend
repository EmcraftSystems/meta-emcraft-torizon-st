KERNEL_INCLUDE:stm32mp25-eval = " \
"

COMPATIBLE_MACHINE:stm32mp25-eval = "stm32mp25-eval"
